# Keil uVision project ASK.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: ASK +hex
  c flags: Optimize=6 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 MAIN.C UART.C AT_PRC.c DELAY.C PWM3.C TIMER0.C DHT11.C
